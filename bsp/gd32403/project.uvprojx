# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f403 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F403VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-gd32f30x
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER, GD32F403
  c include: .;..\..\include;applications;.;drivers;Libraries\CMSIS\GD\GD32F403\Include;Libraries\CMSIS;Libraries\GD32F403_standard_peripheral\Include;packages\EasyFlash-v4.0.0\inc;packages\fal-v0.4.0\inc;packages\freemodbus-latest\modbus\include;packages\freemodbus-latest\modbus\rtu;packages\freemodbus-latest\modbus\ascii;packages\freemodbus-latest\port;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;..\..\components\drivers\include;..\..\components\drivers\sensors;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\termios;..\..\components\net\netdev\include;..\..\components\net\sal_socket\include;..\..\components\net\sal_socket\include\socket;..\..\components\net\sal_socket\include\dfs_net;..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\components\net\sal_socket\include\socket\sys_socket;.\packages\fal-v0.4.0\samples\porting
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_usart.c gd32f403_it.c drv_spi.c drv_i2c.c drv_gpio.c
  group GD32_Lib
    Libraries/GD32F403_standard_peripheral/Source/: gd32f403_fmc.c gd32f403_adc.c gd32f403_bkp.c gd32f403_can.c gd32f403_crc.c gd32f403_ctc.c gd32f403_dac.c gd32f403_dbg.c gd32f403_dma.c gd32f403_exmc.c gd32f403_exti.c gd32f403_fwdgt.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_rtc.c gd32f403_sdio.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c gd32f403_wwdgt.c
    Libraries/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
    Libraries/CMSIS/GD/GD32F403/Source/ARM/: startup_gd32f403.s
  group EasyFlash
    packages/EasyFlash-v4.0.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ./MyApp/: ef_port.c
  group fal
    packages/fal-v0.4.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.4.0/samples/porting/: fal_flash_sfud_port.c
  group FreeModbus
    packages/freemodbus-latest/modbus/functions/: mbfuncdiag.c mbutils.c mbfuncother.c mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
    packages/freemodbus-latest/modbus/rtu/: mbcrc.c mbrtu_m.c
    packages/freemodbus-latest/port/: port.c portevent_m.c portserial_m.c porttimer_m.c user_mb_app_m.c
    packages/freemodbus-latest/modbus/: mb_m.c
    packages/freemodbus-latest/samples/: sample_mb_master.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../components/drivers/spi/sfud/src/: sfud.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Sensors
    ../../components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../components/libc/compilers/common/: gmtime_r.c
    ../../components/libc/termios/: posix_termios.c
  group netdev
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../components/net/sal_socket/src/: sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
software components: CMSIS:CORE 5.1.1
